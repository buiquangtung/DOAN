# Keil uVision project NOKIA_5110.uvproj, settings and files
target NOKIA_5110 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GET_IR +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Code;..\Nokia_5110_mem;..\Nokia_5110_mem\HINH_ANH;..\reprintf;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\LCD2004;..\User\Include;..\LCD16x2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Code
    ../reprintf/: reprintf.c
    ../Code/: main.c stm32f10x_it.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c
    ../User/Source C/: 24cxx.c i2c.c
    ../LCD16x2/: lcd_16x2.c
  group include_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Start up
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
